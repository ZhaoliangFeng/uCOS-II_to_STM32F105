# Keil uVision project UCOSII_STM32F105.uvproj, settings and files
target UCOSII_STM32F105 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: UCOSII_STM32F105 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\BSP;..\STM32_StdPeriph_Library\CMSIS\CoreSupport;..\STM32_StdPeriph_Library\STM32F10x_StdPeriph_Driver\inc;..\UCOSII\Source;..\STM32_StdPeriph_Library\CMSIS\DeviceSupport\ST\STM32F10x;..\STM32_StdPeriph_Library\STM32F10X_CONF_H;..\UCOSII\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_cl.s
  group CMSIS
    ../STM32_StdPeriph_Library/CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../STM32_StdPeriph_Library/CMSIS/CoreSupport/: core_cm3.c
  group STM32_StdPeriph_Library
    ../STM32_StdPeriph_Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group UCOSII
    ../UCOSII/RealView/: os_cpu_a.asm os_cpu_c.c
    ../UCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Bsp
    ../BSP/: stm32f10x_it.c bsp.c led.c
  group Main
    ../Main/: main.c
  group Readme
    ../Readme/: Readme.txt
